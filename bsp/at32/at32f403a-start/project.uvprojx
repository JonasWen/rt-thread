# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT32F403AVGT7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, RT_USING_ARM_LIBC, AT32F403AVGT7, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\msp;..\Libraries\rt_drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\Libraries\AT32_Std_Driver\CMSIS\AT32\AT32F4xx\inc;..\Libraries\AT32_Std_Driver\CMSIS;..\Libraries\AT32_Std_Driver\AT32F4xx_StdPeriph_Driver\inc;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringbuffer.c waitqueue.c pipe.c completion.c ringblk_buf.c workqueue.c dataqueue.c
  group Drivers
    ../Libraries/AT32_Std_Driver/CMSIS/AT32/AT32F4xx/src/mdk/: startup_at32f403avgt7.s
    board/msp/: at32_msp.c system_at32f4xx.c
    board/: board.c
    ../Libraries/rt_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c
  group Kernel
    ../../../src/: irq.c idle.c clock.c kservice.c timer.c scheduler.c memheap.c mempool.c object.c components.c ipc.c mem.c device.c thread.c
  group libc
    ../../../components/libc/compilers/armlibc/: mem_std.c syscalls.c libc.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group Libraries
    ../Libraries/AT32_Std_Driver/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_i2c.c misc.c at32f4xx_xmc.c at32f4xx_gpio.c at32f4xx_bkp.c at32f4xx_usart.c at32f4xx_dbgmcu.c at32f4xx_comp.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_adc.c at32f4xx_dma.c at32f4xx_acc.c at32f4xx_wwdg.c at32f4xx_can.c at32f4xx_spi.c at32f4xx_iwdg.c at32f4xx_sdio.c at32f4xx_dac.c at32f4xx_pwr.c at32f4xx_crc.c at32f4xx_eth.c at32f4xx_flash.c at32f4xx_exti.c at32f4xx_tim.c at32f4xx_ertc.c
