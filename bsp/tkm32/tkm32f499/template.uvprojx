# Keil uVision project template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  scatter file: .\board\linker_scripts\link.sct
