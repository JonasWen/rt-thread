# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: TKM32F499GT8, USE_STDPERIPH_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\..\..\Workspace\rt-thread\libcpu\arm\common;..\..\..\..\..\Workspace\rt-thread\libcpu\arm\cortex-m4;..\..\..\..\..\Workspace\rt-thread\components\drivers\include;..\..\..\..\..\Workspace\rt-thread\components\drivers\include;..\..\..\..\..\Workspace\rt-thread\components\drivers\include;board;board\msp;..\libraries\rt_drivers;..\libraries\rt_drivers\config;..\..\..\..\..\Workspace\rt-thread\components\finsh;.;..\..\..\..\..\Workspace\rt-thread\include;..\..\..\..\..\Workspace\rt-thread\components\libc\compilers\common;..\..\..\..\..\Workspace\rt-thread\components\libc\compilers\common\none-gcc;..\libraries\tkm32f4xx_stdperiph_lib\CMSIS\Device\TKM\TKM32F499\Include;..\libraries\tkm32f4xx_stdperiph_lib\tkm32f499_stdperiph_driver\inc;..\libraries\tkm32f4xx_stdperiph_lib\CMSIS\Include;..\..\..\..\..\Workspace\rt-thread\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../../../Workspace/rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../../../Workspace/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../../Workspace/rt-thread/components/drivers/misc/: pin.c
    ../../../../../Workspace/rt-thread/components/drivers/serial/: serial.c
    ../../../../../Workspace/rt-thread/components/drivers/src/: workqueue.c ringbuffer.c completion.c dataqueue.c ringblk_buf.c pipe.c waitqueue.c
  group Drivers
    board/msp/: tkm32_msp.c
    ../libraries/tkm32f4xx_stdperiph_lib/CMSIS/Device/TKM/TKM32F499/Source/mdk/: startup_tkm32f499.s
    board/: board.c
    ../libraries/rt_drivers/: drv_gpio.c drv_usart.c
  group finsh
    ../../../../../Workspace/rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    ../../../../../Workspace/rt-thread/src/: clock.c device.c thread.c ipc.c object.c components.c kservice.c irq.c idle.c mem.c timer.c scheduler.c
  group libc
    ../../../../../Workspace/rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/tkm32f4xx_stdperiph_lib/tkm32f499_stdperiph_driver/src/: tkm32f499_exti.c tkm32f499_dma.c tkm32f499_uart.c tkm32f499_syscfg.c tkm32f499_pwr.c tkm32f499_misc.c tkm32f499_gpio.c tkm32f499_rcc.c
    ../libraries/tkm32f4xx_stdperiph_lib/CMSIS/Device/TKM/TKM32F499/Source/: system_tkm32f499.c
